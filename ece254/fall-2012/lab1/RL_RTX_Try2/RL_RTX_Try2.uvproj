# Keil uVision project RL_RTX_Try2.uvproj, settings and files
target RL_RTX_Try2 (ARM-ADS)
  device: LPC1768 NXP (founded by Philips)
  cpu: IRAM(0x10000000-0x10007FFF) IRAM2(0x2007C000-0x20083FFF) IROM(0-0x7FFFF) CLOCK(12000000) CPUTYPE("Cortex-M3")
  output: RL_RTX_Try2
  c flags: Optim=1
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x8000
  memory RVCT10: RAM 0x2007c000 size 0x8000
  group Startup Code
    ./: startup_LPC17xx.s
    C:/Keil/ARM/Startup/: RTX_Conf_CM.c
  group Source Code
    ./: GLCD_SPI_LPC1700.c system_LPC17xx.c main.c LED.c
