# Keil uVision project rtx_nolib_demo_stu.uvproj, settings and files
target rtx_nolib_demo_stu SIM (ARM-ADS)
  device: LPC1768 NXP (founded by Philips)
  cpu: IRAM(0x10000000-0x10007FFF) IRAM2(0x2007C000-0x20083FFF) IROM(0-0x7FFFF) CLOCK(12000000) CPUTYPE("Cortex-M3")
  output: rtx_nolib_demo_stu
  c flags: Optim=1
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x8000
  memory RVCT10: RAM 0x2007c000 size 0x8000
  group rtx lib files
    ./rtx_src/: SVC_Table.s HAL_CM3.c rt_Event.c rt_List.c rt_Mailbox.c rt_Mem.c rt_MemBox.c rt_Mutex.c rt_Robin.c rt_Semaphore.c rt_System.c rt_Task.c rt_Time.c rt_Timer.c
  group startup code
    ./src/: startup_LPC17xx.s
  group system code
    ./src/: Retarget.c RTX_Conf_CM.c Serial.c system_LPC17xx.c
  group source code
    ./src/: main.c
